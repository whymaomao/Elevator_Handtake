# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c misc: --C99
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\led;..\HARDWARE\AM2302;..\HARDWARE\timer;..\HARDWARE\KS103;..\HARDWARE\BH1750;..\HARDWARE\sdram;..\HARDWARE\malloc;..\HARDWARE\nandflash;..\HARDWARE\OLED;..\HARDWARE\DS1302;..\HARDWARE\Voltage;..\HARDWARE\WAKEUP;..\HARDWARE\AD;..\HARDWARE\EasyFlash\inc;..\HARDWARE\EasyFlash\plugins\types;..\HARDWARE\EasyFlash\plugins\types\struct2json\inc;..\HARDWARE\Protocol;..\HARDWARE\EEPROM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f429_439xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fmc.c
    ../CORE/: arm_cortexM4lf_math.lib arm_math.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/AM2302/: AM2302.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/KS103/: KS103.c KS103_iic.c
    ../HARDWARE/BH1750/: BH1750.c IIC.c
    ../HARDWARE/sdram/: sdram.c
    ../HARDWARE/malloc/: malloc.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/DS1302/: DS1302.c
    ../HARDWARE/Voltage/: Voltage.c
    ../HARDWARE/WAKEUP/: WAKEUP.c
    ../HARDWARE/AD/: AD.c
    ../HARDWARE/Protocol/: Sensor.c
    ../HARDWARE/nandflash/: nandflash.c
    ../HARDWARE/EEPROM/: eeprom.c EIIC.c
  group EASYFLASH
    ../HARDWARE/EasyFlash/src/: easyflash.c ef_env.c ef_utils.c
    ../HARDWARE/EasyFlash/port/: ef_port.c
    ../HARDWARE/EasyFlash/plugins/types/: ef_types.c
    ../HARDWARE/EasyFlash/plugins/types/struct2json/src/: cJSON.c s2j.c
